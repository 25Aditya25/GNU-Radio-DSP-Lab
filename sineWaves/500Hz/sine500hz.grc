options:
  parameters:
    generate_options: qt_gui
    id: sine1khz
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.sineTable=[0.13053, 0.25882, 0.38268, 0.5, 0.60876, 0.70711, 0.79335, 0.86603, 0.92388, 0.96593, 0.99144, 1,   0.99144, 0.96593, 0.92388, 0.86603, 0.79335, 0.70711, 0.60876, 0.5, 0.38268, 0.25882, 0.13053, 0,  -0.13053,    -0.25882,    -0.38268,    -0.5,    -0.60876,    -0.70711,    -0.79335,    -0.86603,    -0.92388,    -0.96593,    -0.99144,    -1,  -0.99144,    -0.96593,    -0.92388,    -0.86603,    -0.79335,    -0.70711,    -0.60876,    -0.5,    -0.38268,    -0.25882,    -0.13053,    0]
              self.index=0
              self.period=96

          def work(self, input_items, output_items):
              for i in range (0,len(input_items[0])):
                  if self.index%2==0:
                      output_items[0][i] = self.sineTable[int(self.index/2)]
                  elif self.index==95:
                      output_items[0][i] = 0
                  else:
                      output_items[0][i] = (self.sineTable[int((self.index-1)/2)]+self.sineTable[int((self.index-1)/2)+1])/2
                  self.index=(self.index+1)%self.period
              return len(output_items[0])
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_null_source_0, '0', epy_block_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
